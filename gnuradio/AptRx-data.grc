options:
  parameters:
    author: Departamento de Telecomunicaciones - iie - Fing- UdelaR
    category: Custom
    description: Receptor APT NOAA
    generate_options: qt_gui
    id: AptRxData
    output_language: python
    title: Receptor APT NOAA
  states: {}

blocks:
- name: af_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,4,1,1
    label: Volumen audio
    min_len: '100'
    start: '0'
    step: '.1'
    stop: '3'
    value: '1.5'
    widget: dial
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@2
    label: Delay
    start: '0'
    step: '1'
    stop: '5'
    value: '0'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '"/home/hagit/AptRx-data/wav"'
  states: {}
- name: recfile
  id: variable
  parameters:
    value: prefix +"fm_demod/"+ datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".wav"
  states: {}
- name: recfile2
  id: variable
  parameters:
    value: prefix +"am_demod/"+ datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".wav"
  states: {}
- name: recfile3
  id: variable
  parameters:
    value: prefix +"am_demod/"+ datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + "_20800.wav"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    comment: Demodulación FM
    quad_rate: '96000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/hagit/Downloads/2019.01.05.16.36.27(1).dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '5'
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '4000'
    scale: 1/5.
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '.5'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '96000'
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: Registro de archivo de audio
    file: recfile
    format: FORMAT_WAV
    samp_rate: '20800'
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: recfile2
    format: FORMAT_WAV
    samp_rate: 2080*2
  states: {}
- name: blocks_wavfile_sink_1_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: recfile3
    format: FORMAT_WAV
    samp_rate: '20800'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '5'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1300'
    decim: '1'
    gain: '10'
    samp_rate: '20800'
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '96000'
    fc: '0'
    fftsize: '2048'
    gui_hint: tab@0
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '20800'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    showports: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab@1
    label1: ''
    size: '1024'
    srate: '20800'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab@2
    label1: ''
    label2: ''
    nconnections: '2'
    size: '1024'
    srate: '20800'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab@2
    label1: ''
    size: '2080'
    srate: 2080*2
    tr_level: '0.4'
    type: float
    update_time: '.5'
    ymax: '0.4'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: '96000'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '96000'
    fc: '0'
    fftsize: '4096'
    gui_hint: tab@0
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: Cambio tasa de muestreo
    decim: '48000'
    interp: '20800'
    taps: ''
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Senal en recepcion
    label1: Demodulacion FM
    label2: Detector de envolvente
    num_tabs: '3'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', low_pass_filter_0, '0']
- [blocks_delay_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_delay_0, '0', blocks_wavfile_sink_1_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_wavfile_sink_1, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', analog_wfm_rcv_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', blocks_moving_average_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', hilbert_fc_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
